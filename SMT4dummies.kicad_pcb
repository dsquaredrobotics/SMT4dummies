# Repository dsquaredrobotics/SMT4dummies

File README.md:

# SMT4dummies

####Project

SMT4dummies is an SMT soldering practice kit.

###More info on [d-dquared:robotics](http://www.dsquaredrobotics.com/projects/smt4dummies/)

###Get one SMT4dummies kit on our [Store!](http://dsquaredrobotics.bigcartel.com/products)

Published under a GPLv3 lincense. More details on LICENSE.txt

#Get one SMT4dummies kit on our [Store!](http://dsquaredrobotics.bigcartel.com/products)

## KiCad design SMT4dummies.kicad_pcb

Parts:
C1: 22uF
C2: 0.1uF
D1, D9: GREEN
D2, D3, D10: YELLOW
D4, D5, D6, D7, D12: ORANGE
D8: BLUE
D11: RED
D13, D14: 1N4148
IC1: 4520
IC2: LM2902N
IC3: LM555N
J1: USB_2
P1: CONN_2
Q1, Q2, Q3, Q4: BC847; SOT-23
R1, R4, R5: 22K
R2, R3, R6, R10, R11, R12, R13, R19, R20, R21, R22, R23: 150R
R8, R9: 4.7K
R14, R15, R16, R17, R18, R24, R25: 1K
RV1, RV2: 100K
SW1, SW2, SW3, SW4: SW_PUSH

Connections:
+5V: D1.1 (A), D2.1 (A), D3.1 (A), D12.1 (A), IC1.16 (VDD), IC2.4 (V+), IC3.4 (R), IC3.8 (VCC), J1.1, P1.1, R8.1, R14.1, R24.2, RV1.1, SW1.2, SW4.1; also elsewhere on the board
/ANLG_INPUT: IC2.3 (+), IC2.5 (+), IC2.10 (+), IC2.12 (+), RV1.2
/CLK: IC1.1 (CK), R9.1, SW4.2
/DIS: IC3.7 (DIS), R24.1, RV2.2
/THR: C2.1, D13.1 (A), D14.2 (K), IC3.2 (TR), IC3.6 (THR)
GND: C1.2, C2.2, IC1.7 (Reset), IC1.8 (VSS), IC1.9 (CK), IC1.10 (Enable), IC1.15 (Reset), IC2.11 (V-), IC3.1 (GND), J1.4, P1.2 (PM), Q1.2, Q2.2, Q3.2, Q4.2, R9.2, R10.2, R11.2, R12.2, R13.2, R18.2, R19.1, R20.1, R21.1, R22.1, RV1.3, SW2.1, SW3.1; also elsewhere on the board
unnamed: D14.1 (A), RV2.3
unnamed: D12.2 (K), R23.1
unnamed: IC3.3 (Q), R25.2
unnamed: IC2.2 (-), R14.2, R15.1
unnamed: IC2.13 (-), R17.2, R18.1
unnamed: D8.2 (K), R19.2
unnamed: Q1.1, R1.1
unnamed: D1.2 (K), R2.1
unnamed: Q3.1, R5.1, SW3.2
unnamed: D3.2 (K), R6.1
unnamed: Q2.1, R4.2, SW2.2
unnamed: Q4.3, R23.2
unnamed: IC1.2 (Enable), R8.2
unnamed: D8.1 (A), IC2.1
unnamed: D9.1 (A), IC2.7
unnamed: IC2.6 (-), R15.2, R16.1
unnamed: D9.2 (K), R20.2
unnamed: D11.2 (K), R22.2
unnamed: D11.1 (A), IC2.14
unnamed: D10.1 (A), IC2.8
unnamed: D10.2 (K), R21.2
unnamed: D13.2 (K), RV2.1
unnamed: IC2.9 (-), R16.2, R17.1
unnamed: Q1.3, R2.2
unnamed: Q2.3, R3.2, R5.2
unnamed: D6.1 (A), IC1.4 (Q2)
unnamed: D4.1 (A), IC1.6 (Q4)
unnamed: Q3.3, R4.1, R6.2
unnamed: D2.2 (K), R3.1
unnamed: C1.1, R1.2, SW1.1
unnamed: D7.1 (A), IC1.3 (Q1)
unnamed: Q4.1, R25.1
unnamed: D5.1 (A), IC1.5 (Q3)
unnamed: D6.2 (K), R12.1
unnamed: D4.2 (K), R10.1
unnamed: D7.2 (K), R13.1
unnamed: D5.2 (K), R11.1

Notes on the sheet:
Circuit 3: Push-switch operated 4-bit up binary counter
Circuit 1: Time delay switch
Circuit 2: Memory
Circuit 5: 555-based PWM dimmer
Power supply
KiCad needs this
Circuit 4: 4-bit ADC

Board: 2 copper layers, 49.5 x 49.5 mm, 59 parts (37 on the bottom side), 46 nets.

Other parts of the board:
D15: GR; SM0402_LED(generic)
R26, R27, R28: 50R; SM0402(generic)

Their connections:
+5V: D15.1; also elsewhere on the board
GND: R28.2; also elsewhere on the board
unnamed: R27.2, R28.1
unnamed: R26.2, R27.1
unnamed: D15.2, R26.1

## Commit log

2012-09-11 KiCad project structure created
2012-09-12 Started counter circuit
2012-09-12 Binary counter circuit finished
2012-09-13 ADC circuit added to schematic
2012-09-13 555 added, not finished. Power supply added.
2012-09-14 Two choices added to 555 circuit.
2012-09-16 SideA with 2 circuits ERC checked
2012-09-16 Misconnection fixed
2012-09-18 Annotations and ERC error pending
2012-09-18 Annotated and ERC checked
2012-09-18 555 design finished.
2012-09-18 Added USB power supply, ERC performed
2012-09-19 Schematic Annotated
2012-09-19 Blank netlist created
2012-09-22 PCB test uploaded. Testing dimensions
2012-09-30 First values added.
2013-02-06 Some footprints assigned.
2013-02-13 555 circuit changed.
2013-02-14 Potentiometer footprints added.
2013-02-14 Some footprints added to side A.
2013-02-14 More footprints added.
2013-02-19 Op-amp footprint changed.
2013-02-25 NPN transistors changed
2013-02-25 NPN transistors changed II
2013-02-25 Capacitor footprint added
2013-02-25 Merged both sides
2013-02-26 Edited transistor pinout. Created new compoment NPN.
2013-02-26 Changed footprints of LEDs
2013-02-26 LED resistors value (150ohm) added to schematics.
2013-02-27 Added values for resistors.
2013-02-27 All components spitted on the board.
2013-02-27 Some little things placed.
2013-02-27 Fixed capacitor module, some advances on the board
2013-03-01 Added design rules.
2013-03-02 Fixed netlist.
2013-03-02 555 circuit routed.
2013-03-02 Counter (4520) circuit routed.
2013-03-02 Op-amp routed. Some trancks changed.
2013-03-02 Added some space to the upper part of the board.
2013-03-02 Placed power connectors and free space outline.
2013-03-04 Modified counter.
2013-03-04 Some improvements on the board
2013-03-04 Partial routing of sideA
2013-03-04 Ruted GND connections of side A. Added copper layer to front.
2013-03-05 Power traces of side B added.
2013-03-05 Some tracks fixed.
2013-03-05 Everything routed except Vcc on USB.
2013-03-05 Issue with vias fixed.
2013-03-11 Track problems solved.
2013-03-11 Rounded edges. (and added weird thing)
2013-03-13 Fixed boundary-crossing track
2013-03-13 Final layout, ERC performed
2013-03-14 .mod files created for the capacitor and 1206 resistor
2013-03-14 Custom library.mod created
2013-03-14 Test holes added
2013-03-14 Weird ERC error fixed
2013-03-14 Drills removed, text added, copper on corners rounded.
2013-03-15 Added revision number to silkscreen.
2013-03-18 Logos added, relocation of components
2013-03-18 SMT4dummies logo added, some improvements on the silkscreen
2013-03-18 New netlist created with mods from Custom Library
2013-03-18 Added missing files from previous commit
2013-03-21 Fixed pull-up resistor postion on schematic.
2013-03-21 R8 resistor added how it was supposed to be added.
2013-03-23 Minor fixes and layout modification, TSSOP for the 555 timer
2013-03-23 Board ready for the majority of the footprints to be downsized
2013-03-24 Potentiometer vias changed. DRC rules updated.
2013-03-24 Gerbers and README added.
2013-03-25 Smaller components added, ERC performed
2013-03-25 Saving before upgrading KiCAD version.
2013-03-25 Updated KiCAD version files.
2013-03-25 Moved transistor overlayed by logo silkscreen
2013-03-25 Gerbers generated, pad mask clearance 0.01mm
2013-03-25 Fixed NPTH USB hole
2013-03-25 Renamed Gerber files
2013-04-18 License specified more clearly.
2013-04-18 Added license file.
2013-06-08 Schematic fixed. Values added. Netlist updated.
2013-06-14 Changed 0402 resistors to 0603
2013-07-01 Transistor polarity error fixed
2013-07-01 Resistor footprints changed 0402 to 0603
2013-07-02 Power tracks changed.
2013-07-02 Diode SOD123 footprint fixed
2013-07-02 Push switch holes removed (unnecessary), re-routing and error fixed
2013-07-03 Connector changed, USB Mini B to USB Micro B
2013-07-03 LED silkscreen polarity added, sikscreen corrections and minor fixes
2013-07-04 Added TSSOP8 footprint to custom library.
2013-07-04 Erased SideA and sideB legacy files
2013-07-04 Added footprint of SOP14 for the op-amp to Custom Lib
2014-08-13 Some changes made to Custom Library
2015-09-10 Update folder structure
2015-09-10 Add doc images
